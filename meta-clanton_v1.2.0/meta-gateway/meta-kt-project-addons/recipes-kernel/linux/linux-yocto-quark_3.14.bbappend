FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://KT.cfg"

LINUX_VERSION_EXTENSION = "-advantech_quark_512M_2.011_svn171"
